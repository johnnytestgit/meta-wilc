INITSCRIPT_NAME = "hostapd"
INITSCRIPT_PARAMS = "remove"

inherit update-rc.d