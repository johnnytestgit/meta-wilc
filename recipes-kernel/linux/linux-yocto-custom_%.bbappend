COMPATIBLE_MACHINE_sama5d3_xplained = "sama5d3_xplained"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRCREV = "83a9eb4b2f16d9b388daa473a954fb2a563a7ccb"
SRCREV = "8e5d023949cd657cae9298d6a1aad0a635cddc49"